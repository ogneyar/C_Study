<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FlashMLDR187.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>FlashMLDR187</project>
        <configuration>FlashMLDR187</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


