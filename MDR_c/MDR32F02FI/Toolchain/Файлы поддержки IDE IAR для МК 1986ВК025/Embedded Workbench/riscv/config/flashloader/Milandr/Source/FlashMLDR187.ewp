# IAR project FlashMLDR187.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: MLDR187 Milandr MLDR187
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: DEBUG
  OBJCOPY.OOCOutputFile: FlashMLDR187.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: FlashMLDR187.out
  ILINK.IlinkIcfFile: FlashMLDR187.icf
  ILINK.IlinkProgramEntryLabel: main
configuration Release (RISCV)
  as the first configuration, except:
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: flash_loader_ram.c
  group framework
    src/: flash_config.h flash_loader.c flash_loader.h flash_loader_asm.s flash_loader_extra.h
